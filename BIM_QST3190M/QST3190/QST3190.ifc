Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-11-20T15:54:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.0.2.392 - Alternate UI 22.0.2.392
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Nov 20 15:54:09 2023 * Host: DLI-L5jdgnbTSD7 * Database: C:\Users\gba\AppData\Local\Temp\7fba561c-bb19-4d87-bb91-e0729ff5ed61\320fd901-080e-4982-89f2-59a36a708831\ifc * Database version: 5507 * Database creation date: Mon Nov 20 15:54:05 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Nov 20 15:54:06 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Nov 20 15:54:06 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 ft
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_ProductRequirements - Category: Project Information
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:1/4" Head, First Floor
LongName: First Floor; Elevation: 0 ft
Pset_ProductRequirements - Name: First Floor; Category: Levels
Pset_AirSideSystemInformation - Name: First Floor

# IfcBuildingElementProxy: QST3190:QTOO_QST3190_SensorTapForWall, QST3190:QTOO_QST3190_SensorTapForWall:565488
In: First Floor
Type - Material: AISI 316
Type - Pset_ElementShading - Color: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: MasterFormat2014Code - 10 28 16: Bath Accessories; Manufacturer: info@qtoobath.com
Type - Pset_ProductRequirements - Name: QTOO_QST3190_SensorTapForWall; Category: Generic Models
Type - Pset_ProvisionForVoid - Shape: n/a
Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: QTOO_QST3190_SensorTapForWall; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_PrecastConcreteElementGeneral - SerialNumber: n/a
